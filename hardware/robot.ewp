# IAR project robot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.1.3.156; C:\TI-CMSIS-Devices-8636\TI\LM4F\Include; C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\CMSIS\Driver\Include; C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\inc\c; C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\inc\cpp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: robot.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.1.3.156\driverlib\gcc\libdriver.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: distance_controller.cpp distance_controller.h main.cpp motor_controller.cpp motor_controller.h robot_brain.cpp robot_brain.h uart_controller.cpp uart_controller.h
